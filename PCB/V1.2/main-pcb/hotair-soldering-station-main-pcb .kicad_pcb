# Repository kwiecinski/Hotair-and-soldering-iron-station (continued)

## KiCad design PCB/V1.1/front-pcb/Hotair-soldering-station.kicad_pcb

Parts:
J1: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J2: main-board-conn; Con-01x14
J3: hot_on; PinHeader_1x02_P2.54mm_Vertical
R1, R2, R3, R4, R23, R24, R25, R26, R27, R28, R29, R30: 10k; 0805
SW1: HOTAIR_UP; TACTILE_SWITCH_PTH_12MM
SW2: HOTAIR_DOWN; TACTILE_SWITCH_PTH_12MM
SW3: SIRON_UP; TACTILE_SWITCH_PTH_12MM
SW4: SIRON_DOWN; TACTILE_SWITCH_PTH_12MM
SW5: FAN_UP; TACTILE_SWITCH_PTH_12MM
SW6: FAN_DOWN; TACTILE_SWITCH_PTH_12MM
SW7: MENU_UP; TACTILE_SWITCH_PTH_12MM
SW8: MENU_DOWN; TACTILE_SWITCH_PTH_12MM
SW9: MENU_OK; TACTILE_SWITCH_PTH_12MM

Connections:
+3V3: J2.1, R1.2, R2.2, R3.2, R4.2, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2, R29.2, R30.2
GND: J1.2, J2.2, J3.1, SW1.1, SW2.1, SW3.1, SW4.1, SW5.1, SW6.1, SW7.1, SW8.1, SW9.1
HOTAIR_DOWN_SW: J2.8, R25.1, SW2.2
HOTAIR_FAN_DOWN_SW: J2.10, R30.1, SW6.2
HOTAIR_FAN_UP_SW: J2.11, R29.1, SW5.2
HOTAIR_ON_SW: J2.14, J3.2, R27.1
HOTAIR_UP_SW: J2.9, R23.1, SW1.2
MENU_DOWN_SW: J2.5, R1.1, SW8.2
MENU_OK_SW: J2.4, R2.1, SW9.2
MENU_UP_SW: J2.3, R3.1, SW7.2
SOLDER_DOWN_SW: J2.13, R26.1, SW4.2
SOLDER_UP_SW: J2.12, R24.1, SW3.2
T12_ON_SW: J1.3, J2.6, R28.1
WEP_ON_SW: J1.1, J2.7, R4.1

Notes on the sheet:
SMD Rework, Soldering station - Front PCB

Board: 2 copper layers, 99.4 x 61.0 mm, 24 parts (13 on the bottom side), 14 nets.

## KiCad design PCB/V1.1/main-pcb/hotair-soldering-station-main-pcb (1).kicad_pcb

Parts:
C1, C2, C16: 100n; 0805
C3, C4: 10n; 0805
C5: 22n/250V; C_Rect_L13.0mm_W5.0mm_P10.00mm_FKS3_FKP3_MKS4
C6, C8, C12: 100n; 0603
C7: 10n/250V; C_Rect_L18.0mm_W5.0mm_P15.00mm_FKS3_FKP3
C9: 100n; C_0603_1608Metric
C10: 47u/10V; CP_Radial_D5.0mm_P2.00mm
C11: 100u/10V; CP_Radial_D5.0mm_P2.00mm
C13, C18, C19: 10u; 0603
C14, C15: 330u/35V; CP_Radial_D10.0mm_P5.00mm
C20: 1u; 0603
D5: 3v6; D_DO-41_SOD81_P10.16mm_Horizontal
D7: 1N4148; D_MiniMELF
F1: 3,15A; Fuseholder5x20_horiz_SemiClosed_Casing10x25mm
F2: Polyfuse; Fuse_Bourns_MF-RG500
J1: 230VAC_IN; Screw-Terminal-5.00mm-3pin
J2: FRONT_PANEL (IDC r. 2,54); Conn-01x14
J3: EARTH_GND; Screw-Terminal-5.00mm-2pin
J4: 24V_IN (NS-25 r2,54); Conn-01x04-N25-W4P
J5: PSUPPLY (PWZ-02S r.3,96); Hirose_DF63-3P-3.96DSA_03x3.96mm_Straight
J6: HOTAIR_FAN (JST r,2,54); JST_XH_B02B-XH-A_02x2.50mm_Straight
J7: HOTAIR_MEAS (JST r.2,5); JST_XH_B03B-XH-A_03x2.50mm_Straight
J8: HOTAIR_HEATER (PWZ-02S r.3,96); Hirose_DF63-2P-3.96DSA_02x3.96mm_Straight
J9: SOLD_IRON (r.2,54); Conn-01x06-N25-W6P
J10: SOLD_IRON (r.2,54); Conn_1x06
J11: LCD_CON2 (JST r.2.0); JST_PH_B5B-PH-K_1x05_P2.00mm_Vertical
J12: LCD_CON1 (JST r.2.0); JST_PH_B6B-PH-K_1x06_P2.00mm_Vertical
J13: ICP (goldpin r2,54); Conn-01x06
LS1: BUZZER; Buzzer
Q1, Q3, Q5, Q7, Q9, Q11: BC817; SOT-23
Q2: BC807; SOT-23
Q4: Q_PMOS_GDS; TO-220
Q6: BT139-600; TO-220-3_Vertical
Q8, Q10: FP3055LP; TO-220-3_Vertical
R1, R9, R16: 0R; 0805
R2, R3, R4, R5, R7, R19, R22, R29, R31, R35: 10k; 0805
R6: 320R; 0805
R8, R13, R17, R21: 200R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R10, R14, R15: 30k; 0805
R11: 2k; 0805
R12: 390R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R18, R24, R30, R36: 1k; 0805
R20, R28, R37: 4,7k; 0805
R23, R26: 50R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R25, R32: 100R; 0805
R27: 0R; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
R33: 360R; 0805
R34: 220R; 0805
R38, R39, R40: 300R; 0805
U1: MOC3041M; DIP-6_W7.62mm_LongPads
U2, U7: MAX31855KASA; SOIC-8_3.9x4.9mm_P1.27mm
U3: MP1584-Step-Down; MP1584_Mini_3A_Step_Down_Conv
U4: AP1117-ADJ; SOT-223-3_TabPin2
U6: LM358; SO-8_3.9x4.9mm_P1.27mm
U8: STM32F103C6Tx; LQFP-48_7x7mm_P0.5mm

Connections:
+3V3: C6.1, C8.1, C9.1, C11.1, C12.1, C13.1, C18.1, C19.1, C20.1, D5.1 (K), J2.1, J13.2, R19.1, R34.1, R35.1, U2.4 (VCC), U4.2 (VO), U7.4 (VCC), U8.1 (VBAT), U8.9 (VDDA), U8.24 (VDD), U8.36 (VDD), U8.48 (VDD)
+5V: C10.1, C16.1, J11.1, LS1.- (2), R11.1, R24.1, R30.1, R38.1, U1.1, U3.4 (OUT+), U4.3 (VI), U6.8 (P$V+)
+24V: C14.1, C15.1, F2.1, J9.1, J9.2, J10.1, J10.2, Q4.2 (D), R4.1, R5.1, U3.1 (IN+)
AC_230(L): F1.1, J5.1, J8.2
AC_230(N): C5.2, C7.2, J1.2, J5.3, Q6.1 (A1), R12.2
BUZZER: R31.2, U8.38 (PA15)
FAN_SUPPLY: J6.1, Q4.3 (S), R10.1, R14.2
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C16.2, C18.2, C19.2, C20.2, D5.2 (A), J2.14, J4.1, J4.2, J6.2, J11.2, J13.3, Q1.2 (E), Q2.3 (C), Q5.2 (E), Q7.2 (E), Q9.2 (E), Q11.2 (E), R7.2, R9.2, R15.1, R22.1, R27.2, R29.1, R33.2, R40.2, U2.1 (GND), U3.2 (IN-), U3.3 (OUT-), U6.4 (P$V-), U7.1 (GND), U8.8 (VSSA), U8.23 (VSS), U8.35 (VSS), U8.44 (BOOT0), U8.47 (VSS)
GND2: C14.2, C15.2, Q8.3 (S), Q10.3 (S), R27.1
HOTAIR_DOWN_SW: J2.2, U8.10 (PA0)
HOTAIR_FAN_ADC: C2.1, R14.1, R15.2, U8.11 (PA1)
HOTAIR_FAN_DOWN_SW: J2.11, U8.4 (PC15)
HOTAIR_FAN_PWM: R2.1, U8.29 (PA8)
HOTAIR_FAN_UP_SW: J2.13, U8.6 (PD1)
HOTAIR_HEATER_CTRL: R3.1, U8.30 (PA9)
HOTAIR_ON_SW: J2.12, U8.5 (PD0)
HOTAIR_REED_SW: J7.3, U8.20 (PB2)
HOTAIR_TEMP_ADC: R18.2, U8.19 (PB1)
HOTAIR_THERM: J7.1, R1.1, R16.1
HOTAIR_UP_SW: J2.10, U8.28 (PB15)
IRON_T12_HEATER: J10.3, Q10.2 (D)
IRON_T12_HEATER_CTRL: R28.2, U8.42 (PB6)
IRON_T12_MOTION_SW: J10.4, U8.27 (PB14)
IRON_T12_TEMP_ADC: R36.2, U8.18 (PB0)
IRON_T12_THERM: C4.1, J10.5, R35.2, U6.5 (+IN)
IRON_WEP_HEATER: J9.3, J9.4, Q8.2 (D)
IRON_WEP_HEATER_CTRL: R20.2, U8.17 (PA7)
IRON_WEP_THERM: J9.5, U7.3 (T+)
LCD_BACKLIGHT_PWM: R37.2, U8.39 (PB3)
LCD_D4: J12.3, U8.45 (PB8)
LCD_D5: J12.2, U8.43 (PB7)
LCD_D6: J12.1, U8.41 (PB5)
LCD_D7: J11.5, U8.40 (PB4)
LCD_EN: J12.4, U8.46 (PB9)
LCD_RS: J12.6, U8.3 (PC14)
LCD_RW: J12.5, U8.2 (PC13)
MAX31855_HOTAIR_CS: U2.6 (~CS), U8.14 (PA4)
MAX31855_IRON_CS: U7.6 (~CS), U8.13 (PA3)
MENU_DOWN_SW: J2.5, U8.33 (PA12)
MENU_OK_SW: J2.4, U8.32 (PA11)
MENU_UP_SW: J2.8, U8.31 (PA10)
unnamed: C1.1, Q2.1 (B), R2.2
unnamed: C3.1, R16.2, R19.2, U6.3 (+IN)
unnamed: C5.1, R13.2, R17.2
unnamed: C7.1, R26.2
unnamed: D7.1 (K), Q9.3 (C)
unnamed: D7.2 (A), LS1.+ (1), R11.2
unnamed: F1.2, J1.3
unnamed: F2.2, J4.3, J4.4
unnamed: J1.1, J3.1, J3.2
unnamed: J8.1, Q6.2 (A2), R21.1, R23.1
unnamed: J11.3, R39.1
unnamed: J11.4, R38.2, R40.1
unnamed: Q1.1 (B), R3.2
unnamed: Q1.3 (C), R6.1
unnamed: Q2.2 (E), Q3.1 (B), R4.2
unnamed: Q3.2 (E), R7.1, R10.2
unnamed: Q3.3 (C), Q4.1 (G), R5.2
unnamed: Q5.1 (B), R28.1, R29.2
unnamed: Q5.3 (C), R30.2, R32.2
unnamed: Q6.3 (G), R12.1, U1.4
unnamed: Q7.1 (B), R20.1, R22.2
unnamed: Q7.3 (C), R24.2, R25.2
unnamed: Q8.1 (G), R25.1
unnamed: Q9.1 (B), R31.1
unnamed: Q10.1 (G), R32.1
unnamed: Q11.1 (B), R37.1
unnamed: Q11.3 (C), R39.2
unnamed: R1.2, U2.3 (T+)
unnamed: R6.2, U1.2
unnamed: R8.1, U1.6
unnamed: R8.2, R13.1
unnamed: R17.1, R21.2
unnamed: R18.1, U6.1 (OUT), U6.2 (-IN)
unnamed: R23.2, R26.1
unnamed: R33.1, R34.2, U4.1 (ADJ)
unnamed: R36.1, U6.6 (-IN), U6.7 (OUT)
RST: J13.1, U8.7 (NRST)
SOLDER_DOWN_SW: J2.6, U8.25 (PB12)
SOLDER_ON_SW: J2.9, U8.21 (PB10)
SOLDER_SELECT_SW: J2.3, U8.26 (PB13)
SOLDER_UP_SW: J2.7, U8.22 (PB11)
SPI1_MISO: U2.7 (SO), U7.7 (SO), U8.16 (PA6)
SPI1_SCK: U2.5 (SCK), U7.5 (SCK), U8.15 (PA5)
SWCLK: J13.5, U8.37 (PA14)
SWDIO: J13.4, U8.34 (PA13)
THERM_GND: J7.2, J9.6, J10.6, R9.1, U2.2 (T-), U7.2 (T-)
UART_DBG_TX: J13.6, U8.12 (PA2)

Notes on the sheet:
FB resistor in module: 43k
Heater control - T12
Heater controll
Front PCB connector
Soldering iron connector
SMD Rework, Soldering iron - Main PCB
Thermocouple amplifier
Supply connectors, voltage regulation
Fan speed controll
Microcontroller
Thermocouple/Thermistor amplifier
HOT-AIR
TIM14CH1 - Output compare (buzer)
Vdd -> 100n + 10u Vdda -> 100n + 1u Vbat ->100n
HOTAIR connector
TIM3_CH2 - PWM
1,2V @ 12mA
Power supply for 230 -> 24V
Soldering iron
VDD pins: 1x 100nF + 1x10 µF Vbat pin: 100n VDDa pin: 1x100n + 1x1µF
Heater control - WEP
