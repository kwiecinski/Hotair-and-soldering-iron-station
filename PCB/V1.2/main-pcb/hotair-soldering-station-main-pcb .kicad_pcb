# Repository kwiecinski/Hotair-and-soldering-iron-station

File README.md:

# Hotair and soldering iron station
DIY station based on STM32F103C6T8 uC that uses standard WEP/Yihua hotair flask with fan and WEP/Yihua 907A 50W soldering iron + T12 soldering iron. 

# 1. TOOLS
- PCB made in KiCAD v6.0
- 3D model made in DesignSpark Mechanical 5.0
- STM32CubeIDE v1.5 development platform

# 2. Features

# 3. Hardware

### Main PCB schematic

### Front PCB schematic

## KiCad design PCB/V1.2/main-pcb/hotair-soldering-station-main-pcb .kicad_pcb

Parts:
C1, C6, C8, C9, C12, C16: 100n; 0805
C2, C3, C4, C15, C17, C21, C23: 10n; 0805
C5: 22n/250V; C_Rect_L13.0mm_W5.0mm_P10.00mm_FKS3_FKP3_MKS4
C7: 10n/250V; C_Rect_L18.0mm_W5.0mm_P15.00mm_FKS3_FKP3
C10: 47u/10V; CP_Radial_D5.0mm_P2.00mm
C11: 100u/10V; CP_Radial_D5.0mm_P2.00mm
C13, C18, C19: 10u; 0805
C14: 330u/35V; CP_Radial_D10.0mm_P5.00mm
C20: 1u; 0805
C22: 100n; 0603
D1, D2, D7, D8, D10, D13, D14: 1N4148; D_MiniMELF
D3, D11, D15: 3V6; D_MiniMELF
D4, D9: 12V; D_MiniMELF
D5: 3v6; D_DO-41_SOD81_P10.16mm_Horizontal
D6, D12: SR310; D_SMA
F1: 1,5A; Fuseholder5x20_horiz_SemiClosed_Casing10x25mm
J1: 230VAC_IN; Screw-Terminal-5.00mm-3pin
J2: FRONT_PANEL (IDC r. 2,54); Conn-01x14-IDC
J3: EARTH_GND; Screw-Terminal-5.00mm-3pin
J4: 24V_IN (NS-25 r2,54); Conn-01x04-N25-W4P
J5: PSUPPLY (PWZ-02S r.3,96); Hirose_DF63-3P-3.96DSA_03x3.96mm_Straight
J6: HOTAIR_FAN (JST r,2,54); JST_XH_B02B-XH-A_02x2.50mm_Straight
J7: HOTAIR_MEAS (JST r.2,5); JST_XH_B03B-XH-A_03x2.50mm_Straight
J8: HOTAIR_HEATER (PWZ-02S r.3,96); Hirose_DF63-2P-3.96DSA_02x3.96mm_Straight
J9: WEP (r.2,54); Conn-01x06-N25-W6P
J10: T12_power (NS-25 r2,54); Conn-01x05-N25-W4P
J11: LCD_CON2 (JST r.2.0); JST_PH_B5B-PH-K_1x05_P2.00mm_Vertical
J12: LCD_CON1 (JST r.2.0); JST_PH_B6B-PH-K_1x06_P2.00mm_Vertical
J13: ICP (goldpin r2,54); Conn-01x06
J14: Unused_GPIO; SolderWirePad_single_0-8mmDrill
LS1: BUZZER; Buzzer
Q1, Q3, Q7, Q9, Q11, Q12: BC817; SOT-23
Q2, Q8, Q14: BC807; SOT-23
Q4, Q10, Q15: RFP15P05; TO-220-3_V_Thick_Pads
Q5, Q13: BC817; TSOT-23
Q6: BT139-600; TO-220-3_V_Wide_Legs
R1, R56, R57: 47k; 0805
R2, R3, R7, R18, R22, R30, R31, R32, R44, R45, R52, R53, R54, R55, R60: 10k; 0805
R4, R5, R24, R51: 100k; 0805
R6: 320R; 0805
R8, R13, R17: 200R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R9, R58: 0R; 0805
R10: 30k; 0805
R11, R40: 2k; 0805
R12: 390R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R14: 33k; 0805
R15, R20, R29, R36, R43, R63: 2k2; 0805
R16, R35, R59: 1M; 0805
R19, R48, R61: 1k; 0805
R21: 200R; R_Axial_DIN0207_L6.3mm_D2.5mm_P15.24mm_Horizontal
R23, R26: 50R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R25, R50: 100R; 0805
R27: 0R; ShortWire
R28, R49, R62: 200k; 0805
R33: 360R; 0805
R34: 220R; 0805
R37: 4,7k; 0805
R38: 24k; 0805
R39: 300R; 0805
R41, R46: 1k5; 0805
R42, R47: 430R; 0805
RV1: 10k; Potentiometer_Bourns_3314G_Vertical
U1: MOC3041M; DIP-6_W7.62mm_LongPads
U2: MAX31855KASA; SOIC-8_3.9x4.9mm_P1.27mm
U3: MP1584-Step-Down; MP1584_Mini_3A_Step_Down_Conv
U4: AP1117-ADJ; SOT-223-3_TabPin2
U5: LM741; SO-8_3.9x4.9mm_P1.27mm
U6: AD8606; SO-8_3.9x4.9mm_P1.27mm
U8: STM32F103C6Tx; LQFP-48_7x7mm_P0.5mm

Connections:
+3V3: C6.1, C8.1, C9.1, C11.1, C12.1, C13.1, C18.1, C19.1, C20.1, D5.1 (K), J2.1, J13.2, R32.2, R34.1, R53.2, R54.2, R55.2, U2.4 (VCC), U4.2 (VO), U8.1 (VBAT), U8.9 (VDDA), U8.24 (VDD), U8.36 (VDD), U8.48 (VDD)
+5V: C10.1, C16.1, J11.2, LS1.- (2), R11.1, R16.1, R35.1, R38.1, R59.1, U1.1, U3.3 (OUT+), U4.3 (VI), U5.7 (V+), U6.8 (P$V+)
+24V: C14.1, D4.1 (K), D6.1 (K), D9.1 (K), D12.1 (K), J4.3, J4.4, Q4.3 (S), Q5.3 (C), Q10.3 (S), Q13.3 (C), Q15.3 (S), R4.1, R5.1, R24.1, R41.2, R46.2, R51.1, U3.1 (IN+)
AC_230(L): F1.1, J5.1, J8.2
AC_230(N): C5.2, C7.2, J1.2, J5.3, Q6.1 (A1), R12.2
BUZZER: R31.2, U8.38 (PA15)
FAN_SUPPLY: J6.1, Q4.2 (D), R10.1, R14.2
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C16.2, C18.2, C19.2, C20.2, C22.2, C23.2, D1.1 (K), D2.2 (A), D3.2 (A), D5.2 (A), D8.1 (K), D10.2 (A), D11.2 (A), D13.1 (K), D14.2 (A), D15.2 (A), J2.14, J6.2, J11.1, J13.3, Q1.2 (E), Q2.3 (C), Q8.3 (C), Q9.2 (E), Q11.2 (E), Q14.3 (C), R1.1, R7.2, R9.2, R15.1, R19.1, R22.1, R27.2, R33.2, R40.2, R42.1, R44.1, R47.1, R48.1, R56.1, R57.1, R58.2, R61.1, RV1.2, U2.1 (GND), U3.2 (IN-), U3.4 (OUT-), U5.4 (V-), U6.4 (P$V-), U8.8 (VSSA), U8.23 (VSS), U8.35 (VSS), U8.44 (BOOT0), U8.47 (VSS)
GND2: C14.2, J4.1, J4.2, J9.1, J9.2, J10.2, J10.3, R27.1
HOTAIR_DOWN_SW: J2.2, U8.10 (PA0)
HOTAIR_FAN_ADC: C2.1, R14.1, R15.2, U8.11 (PA1)
HOTAIR_FAN_DOWN_SW: J2.11, U8.4 (PC15)
HOTAIR_FAN_PWM: R2.1, U8.29 (PA8)
HOTAIR_FAN_UP_SW: J2.13, U8.6 (PD1)
HOTAIR_HEATER_CTRL: R3.1, U8.30 (PA9)
HOTAIR_ON_SW: J2.12, U8.5 (PD0)
HOTAIR_REED_SW: R30.1, U8.20 (PB2)
HOTAIR_TEMP_ADC: D3.1 (K), R29.2, U8.19 (PB1)
HOTAIR_THERM: J7.1, R16.2, R18.1
HOTAIR_UP_SW: J2.10, U8.33 (PA12)
IRON_T12_HEATER_CTRL: C21.1, R43.2, U8.42 (PB6)
IRON_T12_MOTION_SW: R52.1, U8.27 (PB14)
IRON_T12_TEMP_ADC: D11.1 (K), R36.2, U8.18 (PB0)
IRON_T12_THERM_HEATER: D12.2 (A), J10.4, J10.5, Q15.1 (D), R35.2, R45.1
IRON_WEP_HEATER: D6.2 (A), J9.3, J9.4, Q10.1 (D)
IRON_WEP_HEATER_CTRL: C15.1, R20.2, U8.17 (PA7)
IRON_WEP_THERM+: C17.1, J9.5, R59.2, R60.1, U2.3 (T+)
IRON_WEP_THERM-: C17.2, J9.6, R58.1, U2.2 (T-)
LCD_BACKLIGHT_PWM: R37.2, U8.39 (PB3)
LCD_D4: J12.2, U8.45 (PB8)
LCD_D5: J12.3, U8.43 (PB7)
LCD_D6: J12.4, U8.41 (PB5)
LCD_D7: J12.5, U8.40 (PB4)
LCD_EN: J12.1, U8.46 (PB9)
LCD_RS: J11.4, U8.3 (PC14)
LCD_RW: J11.5, U8.2 (PC13)
MAX31855_IRON_CS: D15.1 (K), R63.2, U2.6 (~CS), U8.13 (PA3)
MENU_DOWN_SW: J2.5, U8.25 (PB12)
MENU_OK_SW: J2.4, U8.22 (PB11)
MENU_UP_SW: J2.8, U8.31 (PA10)
unnamed: C1.1, Q2.1 (B), R2.2, R57.2
unnamed: C3.1, D1.2 (A), D2.1 (K), R18.2, U6.3 (+IN)
unnamed: C4.1, D8.2 (A), D10.1 (K), R45.2, U6.5 (+IN)
unnamed: C5.1, R13.2, R17.2
unnamed: C7.1, R26.2
unnamed: C15.2, Q7.1 (B), R20.1, R22.2
unnamed: C21.2, Q12.1 (B), R43.1, R44.2
unnamed: C23.1, D13.2 (A), D14.1 (K), R60.2, U5.3 (+)
unnamed: D7.1 (K), Q9.3 (C)
unnamed: D7.2 (A), LS1.+ (1), R11.2
unnamed: D9.2 (A), Q12.3 (C), Q13.1 (B), Q14.1 (B), R46.1
unnamed: F1.2, J1.3
unnamed: J1.1, J3.1, J3.2, J3.3
unnamed: J7.3, R30.2, R32.1
unnamed: J8.1, Q6.2 (A2), R21.1, R23.1
unnamed: J10.1, R52.2, R53.1
unnamed: J11.3, R38.2, R40.1
unnamed: J12.6, R39.1
unnamed: Q1.1 (B), R1.2, R3.2
unnamed: Q1.3 (C), R6.1
unnamed: Q2.2 (E), Q3.1 (B), R4.2
unnamed: Q3.2 (E), R7.1, R10.2
unnamed: Q3.3 (C), Q4.1 (G), R5.2
unnamed: D4.2 (A), Q5.1 (B), Q7.3 (C), Q8.1 (B), R41.1
unnamed: Q5.2 (E), Q8.2 (E), R25.1
unnamed: Q6.3 (G), R12.1, U1.4
unnamed: Q7.2 (E), R42.2
unnamed: Q9.1 (B), R31.1, R56.2
unnamed: Q10.2 (G), R24.2, R25.2
unnamed: Q11.1 (B), R37.1
unnamed: Q11.3 (C), R39.2
unnamed: Q12.2 (E), R47.2
unnamed: Q13.2 (E), Q14.2 (E), R50.1
unnamed: Q15.2 (G), R50.2, R51.2
unnamed: R6.2, U1.2
unnamed: R8.1, U1.6
unnamed: R8.2, R13.1
unnamed: R17.1, R21.2
unnamed: R19.2, R28.1, U6.2 (-IN)
unnamed: R23.2, R26.1
unnamed: R28.2, R29.1, U6.1 (OUT)
unnamed: R33.1, R34.2, U4.1 (ADJ)
unnamed: R36.1, R49.2, U6.7 (OUT)
unnamed: R48.2, R49.1, U6.6 (-IN)
unnamed: R61.2, R62.1, U5.2 (-)
unnamed: R62.2, R63.1, U5.6
unnamed: RV1.1, U5.5 (NULL)
unnamed: RV1.3, U5.1 (NULL)
RST: C22.1, J13.1, R55.1, U8.7 (NRST)
SOLDER_DOWN_SW: J2.6, U8.26 (PB13)
SOLDER_ON_SW: J2.9, U8.32 (PA11)
SOLDER_SELECT_SW: J2.3, U8.21 (PB10)
SOLDER_UP_SW: J2.7, U8.28 (PB15)
SPI1_MISO: U2.7 (SO), U8.16 (PA6)
SPI1_SCK: U2.5 (SCK), U8.15 (PA5)
SWCLK: J13.5, U8.37 (PA14)
SWDIO: J13.4, U8.34 (PA13)
THERM_GND: J7.2, R9.1
UART_DBG_TX: J13.6, R54.1, U8.12 (PA2)
UNUSED_GPIO: J14.1, U8.14 (PA4)

Notes on the sheet:
FB resistor in module: 43k
Soldering iron connector
Heater controll
Front PCB connector
SMD Rework, Soldering iron - Main PCB
Thermocouple amplifier
Soldering iron alternative thermocouple amplifier
Supply connectors, voltage regulation
Heater control
Fan speed controll
Soldering iron - T12
Microcontroller
Thermocouple/Thermistor amplifier
HOT-AIR
LCD Connectors contrast and backlight circuit
Vdd -> 100n + 10u Vdda -> 100n + 1u Vbat ->100n
HOTAIR connector
1,2V @ 12mA
Power supply for 230 -> 24V
Soldering iron - WEP
VDD pins: 1x 100nF + 1x10 µF Vbat pin: 100n VDDa pin: 1x100n + 1x1µF

Board: 2 copper layers, 99.5 x 69.5 mm, 140 parts (56 on the bottom side), 100 nets.

## KiCad design PCB/V1.2/front-pcb/Hotair-soldering-station.kicad_pcb

Parts:
C1: 10u; CP_Tantalum_Case-B_EIA-3528-21_Hand
J1: main-board-conn; IDC-Header_2x07_P2.54mm_Vertical
J2: SOLDER_ON_SW; PinHeader_1x03_P2.54mm_Vertical
J3: HOTAIR_ON_SW; PinHeader_1x02_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12: 10k; 0805
SW1: MENU_RIGHT; TACTILE_SWITCH_PTH_12MM
SW2: MENU_LEFT; TACTILE_SWITCH_PTH_12MM
SW3: MENU_OK; TACTILE_SWITCH_PTH_12MM
SW4: SOLDER_UP_TEMP; TACTILE_SWITCH_PTH_12MM
SW5: SOLDER_DOWN_TEMP; TACTILE_SWITCH_PTH_12MM
SW6: FAN_UP; TACTILE_SWITCH_PTH_12MM
SW7: FAN_DOWN; TACTILE_SWITCH_PTH_12MM
SW8: HOTAIR_UP_TEMP; TACTILE_SWITCH_PTH_12MM
SW9: HOTAIR_DOWN_TEMP; TACTILE_SWITCH_PTH_12MM

Connections:
+3V3: C1.1, J1.1, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2
GND: C1.2, J1.14, J2.2, J3.1, SW1.1, SW2.1, SW3.1, SW4.1, SW5.1, SW6.1, SW7.1, SW8.1, SW9.1
HOTAIR_DOWN_SW: J1.8, R11.1, SW9.2
HOTAIR_FAN_DOWN_SW: J1.10, R10.1, SW7.2
HOTAIR_FAN_UP_SW: J1.11, R8.1, SW6.2
HOTAIR_ON_SW: J1.2, J3.2, R12.1
HOTAIR_UP_SW: J1.9, R9.1, SW8.2
MENU_LEFT_SW: J1.5, R1.1, SW2.2
MENU_OK_SW: J1.4, R2.1, SW3.2
MENU_RIGHT_SW: J1.3, R3.1, SW1.2
SOLDER_DOWN_SW: J1.13, R6.1, SW5.2
SOLDER_UP_SW: J1.12, R4.1, SW4.2
T12_ON_SW: J1.6, J2.3, R5.1
WEP_ON_SW: J1.7, J2.1, R7.1

Notes on the sheet:
SMD Rework, Soldering station - Front PCB
SOLDERING IRONS TACT SWITCHES
MAIN CONNECTOR
MENU TACT SWITCHES
HOTAIR TACT SWITCHES

Board: 2 copper layers, 99.4 x 61.0 mm, 25 parts (10 on the bottom side), 14 nets.
