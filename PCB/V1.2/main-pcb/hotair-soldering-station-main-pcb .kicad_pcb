# Repository kwiecinski/Hotair-and-soldering-iron-station (continued)

## KiCad design PCB/Hotair-soldering-station/front-pcb/Hotair-soldering-station.kicad_pcb

Parts:
C1, C2: 100n; 0805
C3: 47u; CP_EIA-3528-21_Kemet-B
J2: main-board-conn; Con-01x14
J3: hot_on; PinHeader_1x02_P2.54mm_Vertical
J4: solder_on; PinHeader_1x02_P2.54mm_Vertical
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8: BC817; SOT-23
Q9, Q10, Q11, Q12, Q13, Q14: BC807; SOT-23
R1, R2, R3, R4, R5, R7, R8, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30: 10k; 0805
R6: 5k6; 0805
R9, R10, R11, R12, R13, R14, R15, R16: 120R; 0805
SW1: HOTAIR_UP; TACTILE_SWITCH_PTH_12MM
SW2: HOTAIR_DOWN; TACTILE_SWITCH_PTH_12MM
SW3, SW5: SIRON_UP; TACTILE_SWITCH_PTH_12MM
SW4, SW6: SIRON_DOWN; TACTILE_SWITCH_PTH_12MM
U1, U2: 74HC595D; SO16
U3: My-Footprints:3-digit-7-segment-display; 3-digit-7-segment-display
U4: 3-dig-7-seg-display-common-anode; 3-digit-7-segment-display

Connections:
7SEG_CLK: J2.12, U1.11 (SCK), U2.11 (SCK)
7SEG_DIN: J2.14, U1.14 (SER)
7SEG_LATCH: J2.13, U1.12 (RCK), U2.12 (RCK)
+3V3: C1.1, C2.1, C3.1, J2.1, Q9.2 (E), Q10.2 (E), Q11.2 (E), Q12.2 (E), Q13.2 (E), Q14.2 (E), R23.2, R24.2, R25.2, R26.2, R27.2, R28.2, R29.2, R30.2, U1.16 (VCC), U2.16 (VCC)
GND: C1.2, C2.2, C3.2, J2.2, J2.3, J3.1, J4.1, Q1.2 (E), Q2.2 (E), Q3.2 (E), Q4.2 (E), Q5.2 (E), Q6.2 (E), Q7.2 (E), Q8.2 (E), SW1.1, SW2.1, SW3.1, SW4.1, SW5.1, SW6.1, U1.8 (GND), U1.10 (SCL), U1.13 (G), U2.8 (GND), U2.10 (SCL), U2.13 (G)
HOTAIR_DIG1: R22.2, U1.3 (QD)
HOTAIR_DIG2: R19.2, U1.2 (QC)
HOTAIR_DIG3: R20.2, U1.1 (QB)
HOTAIR_DOWN_SW: J2.6, R25.1, SW2.2
HOTAIR_FAN_DOWN_SW: J2.9, R30.1, SW6.2
HOTAIR_FAN_UP_SW: J2.8, R29.1, SW5.2
HOTAIR_ON_SW: J2.10, J3.2, R27.1
HOTAIR_UP_SW: J2.7, R23.1, SW1.2
IRON_DIG1: R21.2, U2.4 (QE)
IRON_DIG2: R17.2, U2.1 (QB)
IRON_DIG3: R18.2, U2.15 (QA)
unnamed: Q1.1 (B), R1.2
unnamed: Q1.3 (C), R9.1
unnamed: Q2.1 (B), R2.2
unnamed: Q2.3 (C), R10.1
unnamed: Q3.1 (B), R3.2
unnamed: Q3.3 (C), R11.1
unnamed: Q4.1 (B), R4.2
unnamed: Q4.3 (C), R12.1
unnamed: Q5.1 (B), R5.2
unnamed: Q5.3 (C), R13.1
unnamed: Q6.1 (B), R6.2
unnamed: Q6.3 (C), R14.1
unnamed: Q7.1 (B), R7.2
unnamed: Q7.3 (C), R15.1
unnamed: Q8.1 (B), R8.2
unnamed: Q8.3 (C), R16.1
unnamed: Q9.1 (B), R21.1
unnamed: Q9.3 (C), U3.12 (DIG1)
unnamed: Q10.1 (B), R17.1
unnamed: Q10.3 (C), U3.9 (DIG2)
unnamed: Q11.1 (B), R18.1
unnamed: Q11.3 (C), U3.8 (DIG3)
unnamed: Q12.1 (B), R22.1
unnamed: Q12.3 (C), U4.12 (DIG1)
unnamed: Q13.1 (B), R19.1
unnamed: Q13.3 (C), U4.9 (DIG2)
unnamed: Q14.1 (B), R20.1
unnamed: Q14.3 (C), U4.8 (DIG3)
unnamed: R9.2, U3.3 (DP), U4.3 (DP)
unnamed: R10.2, U3.5 (G), U4.5 (G)
unnamed: R11.2, U3.10 (F), U4.10 (F)
unnamed: R12.2, U3.1 (E), U4.1 (E)
unnamed: R13.2, U3.2 (D), U4.2 (D)
unnamed: R14.2, U3.4 (C), U4.4 (C)
unnamed: R15.2, U3.7 (B), U4.7 (B)
unnamed: R16.2, U3.11 (A), U4.11 (A)
unnamed: U1.9 (QH*), U2.14 (SER)
SEG_A: R8.1, U2.3 (QD)
SEG_B: R7.1, U1.15 (QA)
SEG_C: R6.1, U1.5 (QF)
SEG_D: R5.1, U1.7 (QH)
SEG_DP: R1.1, U1.6 (QG)
SEG_E: R4.1, U2.5 (QF)
SEG_F: R3.1, U2.2 (QC)
SEG_G: R2.1, U1.4 (QE)
SOLDER_DOWN_SW: J2.4, R26.1, SW4.2
SOLDER_ON_SW: J2.11, J4.2, R28.1
SOLDER_UP_SW: J2.5, R24.1, SW3.2

Notes on the sheet:
1,75V @ 10mA 1,78V @ 15mA
8x120R
SMD Rework, Soldering station - Front PCB

Board: 2 copper layers, 120.0 x 70.0 mm, 60 parts (48 on the bottom side), 64 nets.

## Code that names these connections

File code/Soldering station.ioc (part):

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Mcu.Name=STM32F103C(8-B)Tx
Mcu.Package=LQFP48
Mcu.UserName=STM32F103C8Tx
PA0-WKUP.GPIOParameters=GPIO_PuPd,GPIO_Label
PA0-WKUP.GPIO_Label=HOTAIR_ON_SW
PA0-WKUP.GPIO_PuPd=GPIO_NOPULL
PA0-WKUP.Signal=GPIO_Input
PA1.GPIOParameters=GPIO_Label
PA1.GPIO_Label=HOTAIR_FAN_ADC
PA1.Signal=ADCx_IN1
PA10.GPIOParameters=GPIO_Label
PA10.GPIO_Label=HOTAIR_FAN_DOWN_SW
PA10.Signal=GPIO_Input
PA11.GPIOParameters=GPIO_Label
PA11.GPIO_Label=HOTAIR_FAN_UP_SW
PA11.Signal=GPIO_Input
PA12.GPIOParameters=GPIO_Label
PA12.GPIO_Label=HOTAIR_TEMP_UP_SW
PA12.Signal=GPIO_Input
PA13.GPIOParameters=GPIO_Label
PA13.GPIO_Label=SWDIO
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.GPIOParameters=GPIO_Label
PA14.GPIO_Label=SWCLK
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA15.GPIOParameters=GPIO_Label
PA15.GPIO_Label=BUZZER_PWM
PA15.Signal=S_TIM2_CH1_ETR
PA2.GPIOParameters=GPIO_Speed,GPIO_Label
PA2.GPIO_Label=UART_DBG_TX
PA2.GPIO_Speed=GPIO_SPEED_FREQ_LOW
PA2.Mode=Half_duplex(single_wire_mode)
PA2.Signal=USART2_TX
PA3.GPIOParameters=GPIO_Label
PA3.GPIO_Label=MAX31855_IRON_CS
PA3.Signal=GPIO_Output
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=MAX31855_HOTAIR_CS
PA4.Signal=GPIO_Output
PA5.Mode=RX_Only_Simplex_Unidirect_Master
PA5.Signal=SPI1_SCK
PA6.GPIOParameters=GPIO_PuPd
PA6.GPIO_PuPd=GPIO_PULLDOWN
PA6.Mode=RX_Only_Simplex_Unidirect_Master
PA6.Signal=SPI1_MISO
PA7.GPIOParameters=GPIO_Speed,PinState,GPIO_Label
PA7.GPIO_Label=IRON_WEP_HEATER_CTRL
PA7.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PA7.PinState=GPIO_PIN_RESET
PA7.Signal=GPIO_Output
PA8.GPIOParameters=GPIO_Label
PA8.GPIO_Label=HOTAIR_FAN_PWM
PA8.Signal=S_TIM1_CH1
PA9.GPIOParameters=GPIO_Label
PA9.GPIO_Label=HOTAIR_HEATER_CTRL
PA9.Signal=GPIO_Output
PB0.GPIOParameters=GPIO_Label
PB0.GPIO_Label=IRON_T12_TEMP_ADC
PB0.Signal=ADCx_IN8
PB1.GPIOParameters=GPIO_Label
PB1.GPIO_Label=HOTAIR_TEMP_ADC
PB1.Signal=ADCx_IN9
PB10.GPIOParameters=GPIO_Label
PB10.GPIO_Label=MENU_RIGHT_SW
PB10.Signal=GPIO_Input
PB11.GPIOParameters=GPIO_Label
PB11.GPIO_Label=MENU_OK_SW
PB11.Signal=GPIO_Input
PB12.GPIOParameters=GPIO_Label
PB12.GPIO_Label=MENU_LEFT_SW
PB12.Signal=GPIO_Input
PB13.GPIOParameters=GPIO_Label
PB13.GPIO_Label=SOLDER_SELECT_T12_SW
PB13.Signal=GPIO_Input
PB14.GPIOParameters=GPIO_Label
PB14.GPIO_Label=IRON_T12_MOTION_SW
PB14.Signal=GPIO_Input
PB15.GPIOParameters=GPIO_Label
PB15.GPIO_Label=SOLDER_SELECT_WEP_SW
PB15.Signal=GPIO_Input
PB2.GPIOParameters=GPIO_Label
PB2.GPIO_Label=HOTAIR_REED_SW
PB2.Signal=GPIO_Input
PB3.GPIOParameters=GPIO_Label
PB3.GPIO_Label=LED_BACKLIGHT_PWM
PB3.Signal=S_TIM2_CH2
PB4.GPIOParameters=GPIO_Label
PB4.GPIO_Label=LCD_D7
PB4.Signal=GPIO_Output
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=LCD_D6
PB5.Signal=GPIO_Output
PB6.GPIOParameters=GPIO_Label
PB6.GPIO_Label=IRON_T12_HEATER_CTRL
PB6.Signal=S_TIM4_CH1
PB7.GPIOParameters=GPIO_Label
PB7.GPIO_Label=LCD_D5
PB7.Signal=GPIO_Output
PB8.GPIOParameters=GPIO_Label
PB8.GPIO_Label=LCD_D4
PB8.Signal=GPIO_Output
PB9.GPIOParameters=GPIO_Label
PB9.GPIO_Label=LCD_EN
PB9.Signal=GPIO_Output
PC13-TAMPER-RTC.GPIOParameters=GPIO_Label
PC13-TAMPER-RTC.GPIO_Label=LCD_RW
PC13-TAMPER-RTC.Signal=GPIO_Output
PC14-OSC32_IN.GPIOParameters=GPIO_Label
PC14-OSC32_IN.GPIO_Label=LCD_RS
PC14-OSC32_IN.Signal=GPIO_Output
PC15-OSC32_OUT.GPIOParameters=GPIO_Label
PC15-OSC32_OUT.GPIO_Label=HOTAIR_TEMP_DOWN_SW
PC15-OSC32_OUT.Signal=GPIO_Input
PD0-OSC_IN.GPIOParameters=GPIO_Label
PD0-OSC_IN.GPIO_Label=SOLDER_TEMP_UP_SW
PD0-OSC_IN.Signal=GPIO_Input
PD1-OSC_OUT.GPIOParameters=GPIO_Label
PD1-OSC_OUT.GPIO_Label=SOLDER_TEMP_DOWN_SW
PD1-OSC_OUT.Signal=GPIO_Input
RCC.SYSCLKFreq_VALUE=32000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

File code/Soldering-station/Soldering-station.ioc (part):

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Mcu.Name=STM32F030K6Tx
Mcu.Package=LQFP32
Mcu.UserName=STM32F030K6Tx
PA0.GPIOParameters=GPIO_Label
PA0.GPIO_Label=THERM_IRON_ADC
PA0.Mode=IN0
PA0.Signal=ADC_IN0
PA1.GPIOParameters=GPIO_Label
PA1.GPIO_Label=THERM_HOTAIR_ADC
PA1.Mode=IN1
PA1.Signal=ADC_IN1
PA10.GPIOParameters=GPIO_Label
PA10.GPIO_Label=HOTAIR_FAN_UP_SW
PA10.Signal=GPIO_Input
PA11.GPIOParameters=GPIO_Label
PA11.GPIO_Label=HOTAIR_FAN_DOWN_SW
PA11.Signal=GPIO_Input
PA12.GPIOParameters=GPIO_Label
PA12.GPIO_Label=HOTAIR_ON_SW
PA12.Signal=GPIO_Input
PA13.Mode=Serial_Wire
PA13.Signal=SYS_SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_SWCLK
PA15.GPIOParameters=GPIO_Label
PA15.GPIO_Label=EDS18B20_DATA
PA15.Signal=GPIO_Input
PA2.GPIOParameters=GPIO_Label
PA2.GPIO_Label=SOLDER_DOWN_SW
PA2.Signal=GPIO_Input
PA3.GPIOParameters=GPIO_Label
PA3.GPIO_Label=FAN_ADC
PA3.Mode=IN3
PA3.Signal=ADC_IN3
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=BUZZER
PA4.Signal=S_TIM14_CH1
PA5.GPIOParameters=GPIO_Label
PA5.GPIO_Label=DISP_CLK
PA5.Mode=TX_Only_Simplex_Unidirect_Master
PA5.Signal=SPI1_SCK
PA6.GPIOParameters=GPIO_Label
PA6.GPIO_Label=DISP_LATCH
PA6.Signal=GPIO_Output
PA7.GPIOParameters=GPIO_Label
PA7.GPIO_Label=DISP_DIN
PA7.Mode=TX_Only_Simplex_Unidirect_Master
PA7.Signal=SPI1_MOSI
PA8.GPIOParameters=GPIO_Label
PA8.GPIO_Label=HOTAIR_UP_SW
PA8.Signal=GPIO_Input
PA9.GPIOParameters=GPIO_Label
PA9.GPIO_Label=UART_DBG_TX
PA9.Mode=Half_duplex(single_wire_mode)
PA9.Signal=USART1_TX
PB0.GPIOParameters=GPIO_Label
PB0.GPIO_Label=SOLDER_UP_SW
PB0.Signal=GPIO_Input
PB1.GPIOParameters=GPIO_Label
PB1.GPIO_Label=HOTAIR_DOWN_SW
PB1.Signal=GPIO_Input
PB3.GPIOParameters=GPIO_Label
PB3.GPIO_Label=SOLD_IRON_HEATER_CTRL
PB3.Signal=GPIO_Output
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=FAN_PWM
PB5.Signal=S_TIM3_CH2
PB7.GPIOParameters=GPIO_Label
PB7.GPIO_Label=HOTAIR_HEATER_CTRL
PB7.Signal=GPIO_Output
PF0-OSC_IN.GPIOParameters=GPIO_Label
PF0-OSC_IN.GPIO_Label=SOLDER_ON_SW
PF0-OSC_IN.Signal=GPIO_Input
PF1-OSC_OUT.GPIOParameters=GPIO_Label
PF1-OSC_OUT.GPIO_Label=HOTAIR_REED_SW
PF1-OSC_OUT.Signal=GPIO_Input
board=custom

## Commit log

2020-10-03 Schematic add fan regulator, 7seg display, push button
2020-10-04 front schematic done, main schematic add AC circuit
2020-10-06 schematic update
2020-10-07 add heater controll circuit, add sch block structure
2020-10-09 main schematic update, front pcb routing
2020-10-10 Draw main PCB digital schematic parts, add footprints, connectors unification
2020-10-12 routing progress
2020-10-19 add hot air fan buttons
2020-11-05 front PCB - finish
2020-11-05 main pcb smsps fan add
2020-11-05 schematc footprint assign, start pcb routing
2020-11-06 main pcb routing
2020-11-26 PCB desingn update
2020-11-27 PCB design update
2021-01-03 First code generation
2021-01-03 LED display, buzzer and PWM done in SW. Some HW bugs fixed.
2021-01-07 Fan DC converter new design, ADC and PWM done
2021-01-17 Test buzzer, fan, display - done, started temp measuerment
2021-01-23 DS18B20 now working fine
2021-06-29 PCB V1.1 - New fan regulator, add MAX31855
2021-07-02 SCH V2.0
2021-08-05 HV circuit resistor change, update footprints
2021-08-06 Main board routing, remove old 7seg from front panel schematic
2021-10-12 uC change to STM32F103
2021-10-15 Display change to LCD
2021-11-07 Add front panel menu sw, remove lcd, reorganization of uC pinout
2021-11-08 LCD connector main pcb
2022-01-23 Pin assign to new STM32F103, front panel design to new case
2022-01-25 Routing PCB, front panel design progress
2022-01-26 PCB routing done
2022-02-06 Front panel V2, PCB text alignment, drill resize, T12 connector split
2022-02-07 Fixing DRC violations
2022-02-13 PCB silkscreen progress, remove DRC violations
2022-02-14 Main PCB in production! Generate gerber, add silkscreen logos, expose cu on high current traces, some other minor refinements
2022-02-19 Front Panel PCB design
2022-03-06 Configure STM32F1 uC. Fix reset pin and UART problems.
2022-03-10 TIM3 peripheral conflict workaround, add LCD lib
2022-03-11 Larger IDC conenctor pads for front panel
2022-03-14 LCD and MAX31855 working, tested buzzer
2022-03-19 MAX31855 library rewrite
2022-04-13 T12 and WEP tests done
2022-04-18 HOTAIR and button tests done
2022-04-20 Ideas and documentation of station, schematic V1.2 update
2022-04-23 Last code refinement,, hotair reed switch fix
2022-04-26 Repository cleanup
2022-04-26 Main and front PCB schematic rearrangement.
2022-04-28 Enable FreeRtos, Draft of buttons task
2022-04-30 Create new LCD liib with Menu support
2022-05-03 Create Display Task app architecture design
2022-05-03 Add button task to the app
2022-05-03 Remove display task
2022-05-03 Remove local display task
2022-05-03 Menu cleanup
2022-05-04 Schematic V1.2: Drawed concept of new mosfet gate driver, a lot of minor changes
2022-05-05 Schematic and PCB update
2022-05-06 Alternative thermocouple amplifier for WEP
2022-05-10 All knowned problems fixed on schematic, routing mains voltage section
2022-05-11 Routing PCB
2022-05-16 Routing PCB done, resolving DRC violations
2022-05-16 Silkscreen progress
2022-05-17 Front panel rocker switch connector change, preparing pcb for production
2022-05-18 Front panel done
2022-05-19 Add production files
2022-05-21 Add 3D models of hotair holder and cable latch
2022-05-29 Changes in 3D print models
2022-06-01 Designing SMPS case 3D model
2022-06-02 SMPS case done, add 3D print gcode and stl
2022-06-03 Zener diode footprint and orientation change
2022-07-04 Update button handling
2022-07-08 Update view handling to Freertos
2022-08-14 MVC model introduction pt1
2022-08-14 mvc pt 2
2022-08-14 Add Button event queue
2022-08-14 Add ControlTask
2022-08-15 mvc demo
2024-02-21 Update Linguist overrides
