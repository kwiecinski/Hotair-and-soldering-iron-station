# Repository kwiecinski/Hotair-and-soldering-iron-station (continued)

## KiCad design PCB/V1.1/main-pcb/hotair-soldering-station-main-pcb (1).kicad_pcb (continued)

Board: 2 copper layers, 89.4 x 90.9 mm, 95 parts (31 on the bottom side), 88 nets.

## KiCad design PCB/main-pcb/hotair-soldering-station-main-pcb.kicad_pcb

Parts:
C1, C12, C16: 100n; 0805
C2: 470p; 0805
C3: 100u/35V; CP_Radial_D10.0mm_P3.80mm
C4: 8n2; 0805
C5: 22n/250V; C_Rect_L13.0mm_W5.0mm_P10.00mm_FKS3_FKP3_MKS4
C6: 1u; 1206
C7: 10n/250V; C_Rect_L18.0mm_W5.0mm_P15.00mm_FKS3_FKP3
C8, C9: 47u/35V; CP_Radial_D6.3mm_P2.50mm
C10: 47u/10V; CP_Radial_D5.0mm_P2.00mm
C11: 100u/10V; CP_Radial_D5.0mm_P2.00mm
C13: 8,2n; 0805
C14, C15: 330u/35V; CP_Radial_D10.0mm_P5.00mm
C17, C18, C19: 100n; 0603
D1: MBR052; D_SOD-123
D2, D7: 1N4148; D_MiniMELF
D3: 1N5819; D_MELF
D4: 3V6; D_MiniMELF
D5: 3v6; D_DO-41_SOD81_P10.16mm_Horizontal
D6: 3v6; D_MiniMELF
F1, F2, F3: Fuse; Fuseholder5x20_horiz_SemiClosed_Casing10x25mm
J1: 230VAC_IN; Screw-Terminal-5.00mm-3pin
J2: main-board-conn; Conn-01x14
J3: EARTH_GND; Screw-Terminal-5.00mm-2pin
J4: 24V_IN (NS-25 r2,54); Conn-01x04-N25-W4P
J5: PSUPPLY (PWZ-02S r.3,96); Hirose_DF63-3P-3.96DSA_03x3.96mm_Straight
J6: HOTAIR_FAN (JST r,2,54); JST_XH_B02B-XH-A_02x2.50mm_Straight
J7: HOTAIR_MEAS (JST r.2,5); JST_XH_B03B-XH-A_03x2.50mm_Straight
J8: HOTAIR_HEATER (PWZ-02S r.3,96); Hirose_DF63-2P-3.96DSA_02x3.96mm_Straight
J9: SOLD_IRON (r.2,54); Conn-01x06-N25-W6P
J10: PB6; WIRE_PAD_1,3mm
J11: PB4; WIRE_PAD_1,3mm
J12: PB7; WIRE_PAD_1,3mm
J13: ICP (goldpin r2,54); Conn-01x06
L1: 220uH; L_Radial_D10.0mm_P5.00mm_Fastron_07M
LS1: BUZZER; Buzzer
Q1, Q2, Q3, Q7, Q9: BC817; SOT-23
Q4: BC807; SOT-23
Q5: IRLIZ44N; TO-252-2
Q6: BT139-600; TO-220-3_Vertical
Q8: FP3055LP; TO-220-3_Vertical
R1, R25: 100R; 0805
R2, R19: 39k; 0805
R3, R13, R16, R22, R28, R29, R31: 10k; 0805
R4: 910R; 0805
R5, R8, R21, R32: 4k7; 0805
R6: 320R; 0805
R7, R23: 470k; 0805
R9, R27: 0R; 0805
R10, R15: 2x390R; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal
R11: 2k; 0805
R12: 390R; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal
R17: 100R; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal
R18, R30: 510R; 0805
R20: 4,7k; 0805
R24: 1k; 0805
R33: 360R; 0805
R34: 220R; 0805
U1: MOC3041M; DIP-6_W7.62mm_LongPads
U2: LMV324
U3: MP1584-Step-Down; MP1584_Mini_3A_Step_Down_Conv
U4: AP1117-ADJ; SOT-223-3_TabPin2
U5: STM32F030K6Tx; LQFP-32_7x7mm_P0.8mm
U6: DS18B20; TO-92_Inline_Wide

Connections:
7SEG_CLK: J2.12, U5.11 (PA5)
7SEG_DIN: J2.14, U5.13 (PA7)
7SEG_LATCH: J2.13, U5.12 (PA6)
+3V3: C11.1, C17.1, C18.1, C19.1, D5.1 (K), J2.1, J13.2, R32.1, R34.1, U4.2 (VO), U5.1 (VDD), U5.5 (VDDA), U5.17 (VDD), U6.3 (VDD)
+5V: C10.1, C16.1, D2.2 (A), LS1.- (2), R11.1, R24.1, U1.1, U2.4 (V+), U3.4 (OUT+), U4.3 (VI)
+24V: C3.1, C14.1, C15.1, F2.1, J9.1, J9.2, Q5.2 (D), U3.1 (IN+)
AC_230(L): F1.2, F3.1, J1.3
AC_230(N): C5.2, C7.2, J1.2, J5.2, J5.3, Q6.1 (A1), R12.2
BUZZER: R31.2, U5.10 (PA4)
FAN_PWM: R1.1, U5.28 (PB5)
FAN_SUPPLY: C8.1, C9.1, J6.1, L1.2
GND: C1.2, C3.2, C8.2, C9.2, C10.2, C11.2, C12.2, C16.2, C17.2, C18.2, C19.2, D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), J2.2, J2.3, J4.1, J4.2, J6.2, J13.3, Q1.2 (E), Q2.2 (E), Q4.3 (C), Q7.2 (E), Q9.2 (E), R5.1, R9.2, R13.1, R21.1, R22.1, R27.2, R28.1, R33.2, U2.11 (V-), U3.2 (IN-), U3.3 (OUT-), U5.16 (VSS), U5.31 (BOOT0), U5.32 (VSS), U6.1 (GND)
HOTAIR_DOWN_SW: J2.6, U5.15 (PB1)
HOTAIR_FAN_DOWN_SW: J2.9, U5.21 (PA11)
HOTAIR_FAN_UP_SW: J2.8, U5.20 (PA10)
HOTAIR_HEATER_CTRL: R3.1, U5.9 (PA3)
HOTAIR_ON_SW: J2.10, U5.22 (PA12)
HOTAIR_REED_SW: J7.3, U5.3 (PF1)
HOTAIR_THERM: J7.1, R2.1
HOTAIR_UP_SW: J2.7, U5.18 (PA8)
unnamed: C1.1, R2.2, U2.5 (+)
unnamed: C2.1, D1.2 (A), Q2.1 (B), R4.2
unnamed: C2.2, R1.2, R4.1
unnamed: C4.1, R7.2, U2.7, U2.10 (+)
unnamed: C4.2, R5.2, R7.1, U2.6 (-)
unnamed: C5.1, R10.2, R15.1
unnamed: C6.1, D3.1 (K), L1.1, Q5.3 (S)
unnamed: C6.2, D2.1 (K), Q3.3 (C), R8.1
unnamed: C7.1, R17.2
unnamed: C12.1, R19.2, U2.3 (+)
unnamed: C13.1, R23.2, U2.1, U2.12 (+)
unnamed: C13.2, R21.2, R23.1, U2.2 (-)
unnamed: C14.2, C15.2, Q8.3 (S), R27.1
unnamed: D1.1 (K), Q2.3 (C), Q3.1 (B), Q4.1 (B), R8.2
unnamed: D7.1 (K), Q9.3 (C)
unnamed: D7.2 (A), LS1.+ (1), R11.2
unnamed: F1.1, J5.1
unnamed: F2.2, J4.3, J4.4
unnamed: F3.2, J8.2
unnamed: J1.1, J3.1, J3.2
unnamed: J8.1, Q6.2 (A2), R15.2, R17.1
unnamed: J10.1, U5.29 (PB6)
unnamed: J11.1, U5.27 (PB4)
unnamed: J12.1, U5.30 (PB7)
unnamed: Q1.1 (B), R3.2
unnamed: Q1.3 (C), R6.1
unnamed: Q3.2 (E), Q4.2 (E), Q5.1 (G)
unnamed: Q6.3 (G), R12.1, U1.4
unnamed: Q7.1 (B), R20.1, R22.2
unnamed: Q7.3 (C), R24.2, R25.2
unnamed: Q8.1 (G), R25.1
unnamed: Q9.1 (B), R31.1
unnamed: R6.2, U1.2
unnamed: R10.1, U1.6
unnamed: R13.2, R16.1, U2.9 (-)
unnamed: R16.2, R18.1, U2.8
unnamed: R28.2, R29.1, U2.13 (-)
unnamed: R29.2, R30.1, U2.14
unnamed: R32.2, U5.25 (PA15), U6.2 (DQ)
unnamed: R33.1, R34.2, U4.1 (ADJ)
RST: J13.1, U5.4 (NRST)
SOLDERING_IRON_HEATER_GND: J9.3, J9.4, Q8.2 (D)
SOLDERING_IRON_THERM: J9.5, R19.1
SOLDER_DOWN_SW: J2.4, U5.8 (PA2)
SOLDER_ON_SW: J2.11, U5.2 (PF0)
SOLDER_UP_SW: J2.5, U5.14 (PB0)
SOLD_IRON_HEATER_CTRL: R20.2, U5.26 (PB3)
SWCLK: J13.5, U5.24 (PA14)
SWDIO: J13.4, U5.23 (PA13)
THERM_GND: J7.2, J9.6, R9.1
THERM_HOTAIR_ADC: D4.1 (K), R18.2, U5.7 (PA1)
THERM_IRON_ADC: D6.1 (K), R30.2, U5.6 (PA0)
UART_DBG_TX: J13.6, U5.19 (PA9)

Notes on the sheet:
SMD Rework, Soldering iron - Main PCB
1,2V @ 12mA
Soldering iron
HOT-AIR
Front PCB connector
Thermocouple amplifier
Heater controll
Soldering iron connector
HOTAIR connector
Microcontroller
Fan speed controll
Supply connectors, voltage regulation
Power supply for 230 -> 24V
TIM3_CH2 - PWM
TIM14CH1 - Output compare (buzer)
FB resistor in module: 43k

Board: 2 copper layers, 89.4 x 90.9 mm, 91 parts (30 on the bottom side), 73 nets.
